options:
  parameters:
    generate_options: qt_gui
    id: dsp_basics_tutorial
    output_language: python
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: '4625000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: carrier_freq * 3
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_samp_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: audio_samp_rate*4
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: carrier_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '5000'
    low_cutoff_freq: '200'
    samp_rate: audio_samp_rate
    type: fir_filter_fff
    width: '1'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/ubuntu/Documents/Projets/CaptureTaFac/UVB/signal.raw
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/ubuntu/Documents/Projets/CaptureTaFac/UVB/UVB76_FM.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: audio_samp_rate*4
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}

connections:
- [analog_nbfm_tx_0, '0', low_pass_filter_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0, '0', analog_nbfm_tx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
