options:
  parameters:
    generate_options: qt_gui
    id: demode
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: '4625000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: carrier_freq * 3
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_samp_rate
    max_dev: 5e3
    quad_rate: 4*audio_samp_rate
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: carrier_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/ubuntu/Documents/Projets/CaptureTaFac/UVB/signal.raw
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_nbfm_rx_0, '0', audio_sink_0, '0']
- [analog_nbfm_rx_0, '0', qtgui_waterfall_sink_x_1, '0']
- [analog_sig_source_x_0, '0', blocks_divide_xx_0, '0']
- [blocks_divide_xx_0, '0', analog_nbfm_rx_0, '0']
- [blocks_file_source_0, '0', blocks_divide_xx_0, '1']
- [blocks_file_source_0, '0', qtgui_waterfall_sink_x_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
